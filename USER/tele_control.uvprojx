# Keil uVision project tele_control.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tele_control +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM\usart;..\SYSTEM\sys;..\SYSTEM\Delay;..\SYSTEM\Timer_1;..\HARDWARE\BSP;..\HARDWARE\usart_1;..\HARDWARE\Led;..\HARDWARE\OLED;..\HARDWARE\NRF24L01;..\HARDWARE\Control_task;..\HARDWARE\My_ADC;..\HARDWARE\Key
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/Timer_1/: Timer_1.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/Delay/: Delay.c
  group HAREWARE
    ../HARDWARE/BSP/: Bsp.c
    ../HARDWARE/Control_task/: Control_task.c
    ../HARDWARE/NRF24L01/: NRF24L01.c
    ../HARDWARE/My_ADC/: AD.c
    ../HARDWARE/Key/: Key.c
    ../HARDWARE/usart_1/: usart_1.c
    ../HARDWARE/Led/: Led.c
    ../HARDWARE/OLED/: OLED.c OLED_Data.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.6.0
